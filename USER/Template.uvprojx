# Keil uVision project Template.uvprojx, settings and files
target Template (6140001::V6.14.1::.\AC6.14)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: C:\MDK5\ARM\AC6.14\bin\fromelf.exe --bin -o ..\OBJ\out.bin ..\OBJ\Template.axf
  c flags: Optim=6 v6Lang=3 v6Lto=1 wLevel=3
  c define: STM32F10X_HD
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\WARSHIP\LED;..\SYSTEM\ADC;..\SYSTEM\GPIO;..\SYSTEM\IIC_FullSpeed;..\SYSTEM\IIC_HighSpeed;..\SYSTEM\PWM;..\SYSTEM\RCC;..\SYSTEM\SPI;..\SYSTEM\TIMER;..\WARSHIP\OLED;..\WARSHIP\W25Q128;..\WARSHIP\NRF24L01;..\SYSTEM\MyUart;..\WARSHIP\RGB;..\WARSHIP\Encoder;..\WARSHIP\TimeKeeper;..\WARSHIP\SDIO;..\Dev_driver\Dev_ExSRAM;..\Dev_driver\Dev_Disp;..\Dev_driver\Dev_Touch;..\GUI;..\GUI\lvgl;..\GUI\lvgl_driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: startup_stm32f10x_hd.s main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/ADC/: ADC.c
    ../SYSTEM/GPIO/: GPIO.c
    ../SYSTEM/IIC_FullSpeed/: F_IIC.c
    ../SYSTEM/IIC_HighSpeed/: H_IIC.c
    ../SYSTEM/PWM/: PWM.c
    ../SYSTEM/RCC/: RCC.c
    ../SYSTEM/SPI/: SPI.c
    ../SYSTEM/TIMER/: timer.c
    ../SYSTEM/MyUart/: MyUart.c
  group WARSHIP
    ../WARSHIP/LED/: LED.C
    ../WARSHIP/OLED/: oled.c
    ../WARSHIP/W25Q128/: W25Q128.c
    ../WARSHIP/NRF24L01/: NRF24L01.c
    ../WARSHIP/RGB/: RGB.c
    ../WARSHIP/Encoder/: Encoder.c
    ../WARSHIP/TimeKeeper/: TimeKeeper.c
    ../WARSHIP/SDIO/: SDIO_sdcard.c
  group Dev_Disp
    ../Dev_driver/Dev_Disp/: LCD.c LCD_Font.c
  group Dev_Touch
    ../Dev_driver/Dev_Touch/: Touch.c
    ../Dev_driver/Dev_Touch/gt9147/: ctiic.c gt9147.c
  group Dev_mem
    ../Dev_driver/Dev_ExSRAM/: sram.c
  group GUI_core
    ../GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../GUI/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../GUI/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
    ../GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../GUI/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group GUI_drv
    ../GUI/lvgl_driver/: dma.c lv_port_disp.c lv_port_indev.c
software components: CMSIS:CORE 5.2.0
